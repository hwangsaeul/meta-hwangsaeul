DEPENDS_append = " srt" 
PACKAGECONFIG_append = " srt"
EXTRA_OECONF_append = " --enable-libsrt "
